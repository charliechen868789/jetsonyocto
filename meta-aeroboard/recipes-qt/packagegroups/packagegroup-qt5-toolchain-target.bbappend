RDEPENDS:remove = "qtwayland-mkspecs qtwayland-tools"